# Keil uVision project TwoFoot_RobotSomatic.uvprojx, settings and files
target TwoFoot_RobotSomatic (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TwoFoot_RobotSomatic +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\OLED;..\HARDWARE\USART3;..\HARDWARE\ADC;..\HARDWARE\TIMER;..\SYSTEM\pwm;..\SYSTEM\actionArr;..\SYSTEM\deal
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/TIMER/: timer.c
    ../SYSTEM/pwm/: pwm.c
    ../SYSTEM/usart/: usart1.c
    ../SYSTEM/actionArr/: actionArrFile.c
    ../SYSTEM/deal/: deal.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../STM32F10x_FWLib/src/: stm32f10x_adc.c stm32f10x_tim.c misc.c stm32f10x_gpio.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
